# Keil uVision project TZ_NonSecure.uvprojx, settings and files
target FVP Simulation Model (6120000::V6.12::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: TZ_NonSecure
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Secure
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT8: RAM 0x2021f800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x1f800
  group Documentation
    ./: Abstract.txt
  group Secure Library
    ../Secure/Objects/: TZ_Secure_CMSE_Lib.o
    ../Secure/: library_nsc.h
  group Non-Secure Code
    ./: main_ns.c
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Event Groups 10.2.0, RTOS:Heap 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.2.0, CMSIS:RTOS2:FreeRTOS 10.2.0, Device:Startup 1.1.0, Compiler:Event Recorder 1.4.0
