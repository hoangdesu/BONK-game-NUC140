# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x2000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: RTOS:Config 10.2.0, RTOS:Core 9.0.0, RTOS:Event Groups 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.2, CMSIS:RTOS2:FreeRTOS 9.1.0, Device:Startup 1.0.1, Compiler:Event Recorder 1.4.0
